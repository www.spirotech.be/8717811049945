Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC1000_INT-EN.ifc
Time: 2025-08-05T18:30:10+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC600-1000_INT-EN:EVC1000, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC600-1000_INT-EN:EVC1000:2063309
In: F00
Type - Material: Color RGB 040-040-040, Color RAL 1003
Type - Other - Category: Mechanical Equipment; A: 330 mm; B: 1940 mm; Connector Height: 88.45 mm; Connector Length: 318 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC600-1000_INT-EN; Legs: 100 mm; Logo Lenght: 450 mm; Pipe Offset: 220 mm; R: 453 mm; R Void Logo: 900 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19 mm; Height: 2050 mm; Use Nominal Diameter: yes; Width: 900 mm
Type - Identity Data - Article Description: EVC Compact pressure expansion vessel - replaceable membrane - 1000 ltr; Article Type: EVC1000; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: EVC Compact pressure expansion vessel - replaceable membrane - 1000 ltr; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 23.13; GLN: 8717811000007; GTIN: 8717811049945; Manufacturer: Spirotech; Manufacturer Art. No.: EVC1000; Manufacturer URL: https://www.spirotech.com/8717811049945; MEPcontent Class: EXPANSIONVESSEL; Model: EVC1000; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EVC1000; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Flow: 0 m3/s; Max. Safety Temperature: 110 C; Standard Gas Pressure: 300000 Pa; Volume: 1 m3; Weight: 135 kg
Type - Visibility - EVC1000: yes; EVC600: no; EVC800: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EVC1000; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EVC1000
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC600-1000_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVC600-1000_INT-EN: EVC1000; Type: EVC1000; Type Id: 2063290
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 16.0551 m2; Volume: 1.07319 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort, InPort_2063309_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE
